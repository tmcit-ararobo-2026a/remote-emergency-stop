# Repository tmcit-ararobo-2026a/remote-emergency-stop

File README.md:

# Remote Emergency Stop

ロボットなどの遠隔非常停止
920MHzの通信可能

## 目次

1. [概要](#1-概要)
2. [ドキュメント](#2-ドキュメント)
3. [ビルド・使い方](#3-ビルド使い方)
4. [システム構成](#4-システム構成)
5. [ライセンス](#5-ライセンス)

## 1. 概要

<!-- プロジェクトの目的・背景・解決する課題を記述 -->

## 2. ドキュメント

| ドキュメント | 説明 |
| :-: | :-: |
| [CONTRIBUTING.md](./CONTRIBUTING.md) | 開発フロー・コミット規約・コーディング規約 |
| [docs/coding-rules.md](./docs/coding-rules.md) | コーディング規約の詳細 |
| [docs/uml/](./docs/uml/) | UML図 |

## 3. ビルド・使い方

<!-- ビルドのやり方 -->
<!-- 使い方 -->

## 4. システム構成

<!-- ROS2ノード構成・STM32との通信方式・ハードウェア構成 等 -->
<!-- 依存クラスが3つ以上ある場合は docs/uml/ にUML図を作成し、ここにリンクする -->

## 5. ライセンス

本リポジトリは [MITライセンス](./LICENSE) のもとで公開されています。

## KiCad design remote-ems-reciever/remote-ems-reciever.kicad_pcb

Parts:
C1, C4: 4.7u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C2, C3, C5, C6, C7, C8, C9: 0.1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C10: 0.47u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D1, D2, D3, D4: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
IC1: Wio-E5; 114993121; Mouser Part Number 713-114993121
IC2: MCP2562; SOIC127P600X175-8N; Mouser Part Number 771-TJA1441AT/0Z
J1: Conn_Coaxial; SMA_Molex_73251-2120_EdgeMount_Horizontal
J2, J3, J5: Conn_01x04; JST_XH_S4B-XH-A_1x04_P2.50mm_Horizontal
J4: Conn_01x04_Pin; PinHeader_1x04_P2.54mm_Vertical
JP1: Jumper_2_Open; TestPoint_2Pads_Pitch2.54mm_Drill0.8mm
Q1: BSS138; SOT-23
R1, R5, R9, R10: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R2: 120; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R3, R6, R7, R8: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R4: 470; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R11: 100; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW1, SW2, SW3: SW_Push; switch_TVAF06-A020B-R
SW4: SW_DIP_x02; SW_DIP_SPSTx02_Slide_9.78x7.26mm_W7.62mm_P2.54mm
U1: STM32G431K8Tx; LQFP-32_7x7mm_P0.8mm
U2: NJM12888F33; SOT-23-5_HandSoldering

Connections:
+3.3V: C1.1, C3.1, C4.1, C5.1, C8.1, C10.1, IC1.1 (VCC), IC2.5 (VIO), J4.4, J5.2, R3.1, R9.1, R10.1, U1.1 (VDD), U1.15 (VDDA), U1.17 (VDD), U2.5 (VOUT)
+5V: C7.1, C9.1, IC2.3 (VCC), J2.3, J3.3, R6.1, U2.1 (VIN), U2.3 (CONTROL)
CANH: IC2.7 (CANH), J2.4, J3.4, R2.1
CANL: IC2.6 (CANL), J2.2, J3.2, JP1.2 (B)
CAN_RX: IC2.4 (RXD), U1.21 (PA11)
CAN_TX: IC2.1 (TXD), U1.22 (PA12)
DIP1: R9.2, SW4.1, U1.27 (PB4)
DIP2: R10.2, SW4.2, U1.28 (PB5)
GNDD: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), IC1.2 (GND_1), IC1.14 (GND_2), IC1.16 (GND_3), IC1.22 (GND_4), IC2.2 (GND), IC2.8 (S), J1.2 (Ext), J2.1, J3.1, J4.2, J5.4, Q1.2 (S), R1.2, R4.2, R5.2, SW1.1, SW3.1, SW4.3, SW4.4, U1.14 (VSSA), U1.16 (VSS), U1.32 (VSS), U2.2 (GND)
LED1: R7.1, U1.26 (PB3)
LED2: R8.1, U1.25 (PA15)
NRST: C2.1, SW1.2, U1.4 (PG10)
unnamed: D1.2 (A), R3.2
unnamed: D2.2 (A), R6.2
unnamed: D3.2 (A), R7.2
unnamed: D4.2 (A), R8.2
unnamed: IC1.24 (PB13), SW2.2
unnamed: C6.1, IC1.17 (RST), Q1.3 (D), SW3.2
unnamed: JP1.1 (A), R2.2
unnamed: Q1.1 (G), R5.1, R11.2
unnamed: R4.1, SW2.1
unnamed: R1.1, U1.31 (PB8)
SW1: U1.5 (PA0)
SWCLK: J4.3, U1.24 (PA14)
SWDIO: J4.1, U1.23 (PA13)
UART_RX: J5.1, U1.30 (PB7)
UART_TX: J5.3, U1.29 (PB6)
Wio-RST: R11.1, U1.6 (PA1)
Wio_RX: IC1.10 (PB6), U1.8 (PA3)
Wio_TX: IC1.9 (PB7), U1.7 (PA2)
antenna: IC1.15 (RFIO), J1.1 (In)

Notes on the sheet:
CAN
Wio
RST
CANトランシーバー
レギュレータ
UART
stm32
LED
STLink

Board: 2 copper layers, 50.0 x 50.0 mm, 40 parts (2 on the bottom side), 30 nets.

File remote-ems-reciever/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C1, C4",0603,2,4.7u,
C10,0603,1,0.47u,
"C2, C3, C5, C6, C7, C8, C9",0603,7,0.1u,
"D1, D2, D3, D4",0603,4,LED,
IC1,114993121,1,Wio-E5,
IC2,SOIC127P600X175-8N,1,MCP2562,
J1,SMA_Molex_73251-2120_EdgeMount_Horizontal,1,Conn_Coaxial,
"J2, J3, J5",JST_XH_S4B-XH-A_1x04_P2.50mm_Horizontal,3,Conn_01x04,
J4,PinHeader_1x04_P2.54mm_Vertical,1,Conn_01x04_Pin,
JP1,TestPoint_2Pads_Pitch2.54mm_Drill0.8mm,1,Jumper_2_Open,
Q1,SOT-23,1,BSS138,
"R1, R10, R5, R9",0603,4,10k,
R11,0603,1,100,
R2,0603,1,120,
"R3, R6, R7, R8",0603,4,1k,
R4,0603,1,470,
"SW1, SW2, SW3",switch_TVAF06-A020B-R,3,SW_Push,
SW4,SW_DIP_SPSTx02_Slide_9.78x7.26mm_W7.62mm_P2.54mm,1,SW_DIP_x02,
U1,LQFP-32_7x7mm_P0.8mm,1,STM32G431K8Tx,
U2,SOT-23-5_HandSoldering,1,NJM12888F33,

## KiCad design remote-ems-transmitter/remote-ems-transmitter.kicad_pcb

Parts:
BAR1: OSX05201-GGR1
BAR2: OSX40601-AO
BT1: Battery_Cell; JST_PH_B2B-PH-K_1x02_P2.00mm_Vertical
C1, C4, C8, C9: 4.7u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C2, C3, C5, C6, C7, C10: 0.1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C11: 0.47u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C12, C13, C14, C15: 0.1uf; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D1, D2: LED; LED_D5.0mm_FlatTop
D3: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
F1: Fuse; 355715
IC1: Wio-E5; 114993121; Mouser Part Number 713-114993121
J1: Conn_01x04_Pin; PinHeader_1x04_P2.54mm_Vertical
J2, J3: Conn_01x02; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J4: Conn_Coaxial; SMA_Molex_73251-2120_EdgeMount_Horizontal
J5: USB_C_Receptacle_USB2.0; USB_C_Receptacle_HRO_TYPE-C-31-M-12
J6: Conn_01x02_Pin; PinHeader_1x02_P2.54mm_Vertical
Q1, Q2: BSS138; SOT-23
R1, R2, R5, R6, R8, R20, R22: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R3, R21: 100; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R4, R9, R10, R11, R12, R13, R14, R15, R16, R17, R18: 4.7k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R7: 470; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R19: 2k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R23: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW1, SW2, SW3: SW_Push; switch_TVAF06-A020B-R
SW4: 2MS1-T2-B4-VS2-Q-E-S; 2MS1-T1-B4-VS2-Q-E-S
U1: STM32G431K8Tx; LQFP-32_7x7mm_P0.8mm
U2: MCP73831-2-OT; SOT-23-5
U3: NJM12888F33; SOT-23-5_HandSoldering
U4, U5: XC8111AA01MR-G; SOT-23-5_HandSoldering

Connections:
+3.3V: BAR2.1 (A), BAR2.4 (A), BAR2.5 (A), BAR2.8 (K), C1.1, C3.1, C4.1, C5.1, C11.1, IC1.1 (VCC), J1.4, R1.1, R20.1, U1.1 (VDD), U1.15 (VDDA), U1.17 (VDD), U3.5 (VOUT)
+BATT: C12.1, R5.1, SW4.1 (C), U4.1 (VIN), U4.3 (CE)
ADC: R5.2, R6.1, U1.5 (PA0)
GNDD: BT1.2 (-), C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, D2.1 (K), D3.1 (K), IC1.2 (GND_1), IC1.14 (GND_2), IC1.16 (GND_3), IC1.22 (GND_4), J1.2, J2.2, J3.2, J4.2 (Ext), J5.A1 (GND), J5.A12 (GND), J5.B1 (GND), J5.B12 (GND), Q1.2 (S), Q2.2 (S), R2.2, R6.2, R7.2, R8.2, R9.2, R10.2, R14.2, R15.2, R16.2, R17.2, R18.2, R19.2, R22.2, SW1.1, SW3.1, U1.14 (VSSA), U1.16 (VSS), U1.32 (VSS), U2.2 (V_{SS}), U3.2 (GND), U4.2 (GND), U5.2 (GND)
LED1: D2.2 (A), U1.27 (PB4)
LED_opt_supply0: BAR1.1 (A), U1.13 (PB0)
LED_opt_supply1: BAR1.2 (A), U1.12 (PA7)
LED_opt_supply2: BAR1.3 (A), U1.11 (PA6)
LED_opt_supply3: BAR1.4 (A), U1.18 (PA8)
LED_opt_supply4: BAR1.5 (A), U1.19 (PA9)
LED_opt_supply_SW: J2.1, R20.2, U1.9 (PA4)
NRST: C2.1, SW1.2, U1.4 (PG10)
unnamed: BAR1.6 (K), R14.1
unnamed: BAR1.7 (K), R15.1
unnamed: BAR1.8 (K), R16.1
unnamed: BAR1.9 (K), R17.1
unnamed: BAR1.10 (K), R18.1
unnamed: BAR2.2 (A), R13.1
unnamed: BAR2.3 (A), R12.1
unnamed: BAR2.6 (K), R11.1
unnamed: BAR2.7 (K), R4.1
unnamed: BT1.1 (+), F1.2
unnamed: D3.2 (A), R23.2
unnamed: IC1.24 (PB13), SW2.2
unnamed: C6.1, IC1.17 (RST), Q1.3 (D), SW3.2
unnamed: J5.A5 (CC1), R10.1
unnamed: J5.B5 (CC2), R9.1
unnamed: Q1.1 (G), R3.2, R8.1
unnamed: Q2.3 (D), R4.2, R11.2, R12.2, R13.2
unnamed: Q2.1 (G), R21.2, R22.1
unnamed: R7.1, SW2.1
unnamed: C9.1, F1.1, SW4.2 (B), U2.3 (V_{BAT})
unnamed: R2.1, U1.31 (PB8)
unnamed: R19.1, U2.5 (PROG)
STAT: D1.1 (K), U2.1 (STAT)
SW: J3.1, R1.2, U1.10 (PA5)
SWCLK: J1.3, U1.24 (PA14)
SWDIO: J1.1, U1.23 (PA13)
UART_RX: J6.2, U1.30 (PB7)
UART_TX: J6.1, U1.29 (PB6)
VBUS: C7.1, C8.1, C14.1, D1.2 (A), J5.A4 (VBUS), J5.A9 (VBUS), J5.B4 (VBUS), J5.B9 (VBUS), R23.1, U2.4 (V_{DD}), U5.1 (VIN), U5.3 (CE)
VCC: C10.1, C13.1, C15.1, U3.1 (VIN), U3.3 (CONTROL), U4.5 (OUT), U5.5 (OUT)
Wio-RST: R3.1, U1.6 (PA1)
Wio_RX: IC1.10 (PB6), U1.8 (PA3)
Wio_TX: IC1.9 (PB7), U1.7 (PA2)
antenna: IC1.15 (RFIO), J4.1 (In)
emergency_stop_LED: R21.1, U1.20 (PA10)

Notes on the sheet:
USB
書き込み
battery
stm32
Wio
LED
バッテリー残量用 押すと数秒だけLEDアレイが光る
RST
非常停止

Board: 2 copper layers, 65.0 x 30.0 mm, 63 parts (24 on the bottom side), 47 nets.

File remote-ems-transmitter/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
BAR1,OSX05201-GGR1,1,OSX05201-GGR1,
BAR2,OSX40601-AO,1,OSX40601-AO,
BT1,JST_PH_B2B-PH-K_1x02_P2.00mm_Vertical,1,Battery_Cell,
"C1, C4, C8, C9",0603,4,4.7u,
"C10, C2, C3, C5, C6, C7",0603,6,0.1u,
C11,0603,1,0.47u,
"C12, C13, C14, C15",0603,4,0.1uf,
"D1, D2",LED_D5.0mm_FlatTop,2,LED,
D3,0603,1,LED,
F1,355715,1,Fuse,
IC1,114993121,1,Wio-E5,
J1,PinHeader_1x04_P2.54mm_Vertical,1,Conn_01x04_Pin,
"J2, J3",JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical,2,Conn_01x02,
J4,SMA_Molex_73251-2120_EdgeMount_Horizontal,1,Conn_Coaxial,
J5,USB_C_Receptacle_HRO_TYPE-C-31-M-12,1,USB_C_Receptacle_USB2.0,
J6,PinHeader_1x02_P2.54mm_Vertical,1,Conn_01x02_Pin,
"Q1, Q2",SOT-23,2,BSS138,
"R1, R2, R20, R22, R5, R6, R8",0603,7,10k,
"R10, R11, R12, R13, R14, R15, R16, R17, R18, R4, R9",0603,11,4.7k,
R19,0603,1,2k,
"R21, R3",0603,2,100,
R23,0603,1,1k,
R7,0603,1,470,
"SW1, SW2, SW3",switch_TVAF06-A020B-R,3,SW_Push,
SW4,2MS1-T1-B4-VS2-Q-E-S,1,2MS1-T2-B4-VS2-Q-E-S,
U1,LQFP-32_7x7mm_P0.8mm,1,STM32G431K8Tx,
U2,SOT-23-5,1,MCP73831-2-OT,
U3,SOT-23-5_HandSoldering,1,NJM12888F33,
"U4, U5",SOT-23-5_HandSoldering,2,XC8111AA01MR-G,

## Commit log

2026-05-16 回路図完成 LED等の一部はまだ
2026-05-17 remote-ems-transmitter ビア、シルク、LED以外完成
2026-05-17 remote-ems-reciever ビア、シルク、LED以外完成
2026-05-17 LED周り修正
2026-05-19 LED仕様変更
2026-05-21 ビア打ち、シルク修正中 残りは別日に対応します
2026-05-25 FETの向きを修正 ガーバー出力
